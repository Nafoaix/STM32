# Keil uVision project F103.uvprojx, settings and files
target REG-LED (6160000::V6.16::ARMCLANG)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: F103 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Source Group 1
    ./: startup_stm32f10x_hd.s main.c stm32f10x.h stm32f10x_gpio.c stm32f10x_gpio.h
